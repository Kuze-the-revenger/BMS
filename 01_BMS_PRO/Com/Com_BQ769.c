#include "Com_BQ769.h"

static uint16_t last_tempr_idx = 125-25 ; // 25℃
static int last_res = 10000;
// 热敏电阻和温度对照表
static int res_tempr_lookup_table[181] = {
    324, 333, 342, 351, 361, 371,                                     // 120 ~ 125℃  
    382, 393, 404, 415, 427, 439, 451, 464, 478, 491,                // 110 ~ 119℃
    505, 520, 535, 551, 567, 584, 601, 619, 637, 657,                // 100 ~ 109℃
    676, 697, 718, 740, 763, 787, 811, 837, 863, 890,                // 90 ~ 99℃
    919, 948, 979, 1011, 1044, 1078, 1113, 1150, 1189, 1228,         // 80 ~ 89℃
    1270, 1313, 1358, 1404, 1452, 1503, 1555, 1610, 1666, 1725,      // 70 ~ 79℃
    1786, 1850, 1917, 1986, 2058, 2133, 2211, 2293, 2377, 2466,      // 60 ~ 69℃
    2558, 2654, 2754, 2859, 2968, 3081, 3200, 3324, 3453, 3588,      // 50 ~ 59℃
    3728, 3875, 4029, 4189, 4357, 4532, 4716, 4907, 5108, 5318,      // 40 ~ 49℃
    5537, 5767, 6008, 6259, 6523, 6800, 7090, 7394, 7712, 8047,      // 30 ~ 39℃
    8397, 8765, 9151, 9557, 10000, 10431, 10901, 11395, 11915, 12461, // 20 ~ 29℃
    13036, 13641, 14277, 14947, 15652, 16395, 17177, 18000, 18868, 19783, // 10 ~ 19℃
    20746, 21762, 22833, 23962, 25152, 26408, 27732, 29128, 30601, 32116, // 1 ~ 9℃
    33795, 35524, 37349, 39274, 41306, 43450, 45712, 48100, 50620, 53280, // -9 ~ 0℃
    56087, 59052, 62183, 65489, 68982, 72672, 76574, 80699, 85063, 89682, // -19 ~ -10℃
    94573, 99756, 105252, 111084, 117280, 123866, 130877, 138347, 146315, 154827, // -29 ~ -20℃
    163931, 173681, 184139, 195372, 207454, 220466, 234498, 249649, 266022, 283730, // -39 ~ -30℃
    302890, 323623, 346049, 370283, 396426, 424553, 454704, 486858, 520911, 556644, // -49 ~ -40℃
    593686, 631466, 669165, 705664, 739500 // -55 ~ -50℃
};

static int last_soc=3599;
static uint16_t last_soc_idx=30;
// 电压和SOC（剩余电量）对照表
static int battery_soc_ocv_lookup_table[101] = {
    3282,                                                       // 0% SOC
    3309, 3334, 3357, 3378, 3398, 3417, 3434, 3449, 3464, 3477, // 1%~10% SOC
    3489, 3500, 3510, 3520, 3528, 3536, 3543, 3549, 3555, 3561, // 11%~20% SOC
    3566, 3571, 3575, 3579, 3583, 3586, 3590, 3593, 3596, 3599, // 21%~30% SOC
    3602, 3605, 3608, 3611, 3615, 3618, 3621, 3624, 3628, 3632, // 31%~40% SOC
    3636, 3640, 3644, 3648, 3653, 3658, 3663, 3668, 3674, 3679, // 41%~50% SOC
    3685, 3691, 3698, 3704, 3711, 3718, 3725, 3733, 3741, 3748, // 51%~60% SOC
    3756, 3765, 3773, 3782, 3791, 3800, 3809, 3818, 3827, 3837, // 61%~70% SOC
    3847, 3857, 3867, 3877, 3887, 3897, 3908, 3919, 3929, 3940, // 71%~80% SOC
    3951, 3962, 3973, 3985, 3996, 4008, 4019, 4031, 4043, 4055, // 81%~90% SOC
    4067, 4080, 4092, 4105, 4118, 4131, 4145, 4158, 4172, 4185, // 91%~100% SOC
};

/**
 * @brief 查表函数
 */
static uint16_t lookup_table(int *table, uint16_t table_num,   int value, uint16_t *last_idx, int *last_value)
{
    uint16_t cur_idx = *last_idx;
    while (cur_idx > 0 && cur_idx < table_num)
    {
        // 比较寻找索引
        if (value >= table[cur_idx] && value < table[cur_idx + 1])
        {
            *last_idx = cur_idx;
            *last_value = table[cur_idx];
            return cur_idx;
        }
        // 向上寻找
        if ( value > *last_value   )
        {
            cur_idx++;
        }
        // 向下寻找
        else
        {
            cur_idx--;
        }
    }
    //出边界
     return cur_idx;
 
} 

  
/**
 * @brief 电压转换为温度
 * 
 * @param uiADCV 热敏电阻阻值
 * @return uint8_t 温度,单位是℃
 */
int8_t Com_BQ769_GetTemperatureByRes(int res )
{
   uint8_t idx=  lookup_table(res_tempr_lookup_table,181,res,&last_tempr_idx,&last_res);
   int tempr =  125-idx ;
   return  tempr;
}

/**
 * @brief 锂电池开路电压(OCV)与荷电状态(SOC)对应查找表
 * @note 电压单位：mV，SOC范围：0%~100%，每1%一个采样点
 *       数组索引直接对应SOC百分比值
 *       例如：索引0对应0% SOC，索引50对应50% SOC，索引100对应100% SOC
 *
 * 典型电压点：
 * 0% SOC:   3282mV    50% SOC:  3679mV    100% SOC: 4185mV
 * 10% SOC:  3477mV    60% SOC:  3748mV
 * 20% SOC:  3561mV    80% SOC:  3940mV
 */
uint8_t Com_BQ769_GetSocByVol(uint16_t vol)
{
    uint8_t soc= lookup_table(battery_soc_ocv_lookup_table,101,vol,&last_soc_idx,&last_soc);
    return soc;
}
